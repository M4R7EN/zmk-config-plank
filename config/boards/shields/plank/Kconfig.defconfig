## config/boards/shields/plank/Kconfig.defconfig
```kconfig
if SHIELD_PLANK

config ZMK_KEYBOARD_NAME
	default "Plank"

endif

CONFIG_BUILD_OUTPUT_UF2=y
```
